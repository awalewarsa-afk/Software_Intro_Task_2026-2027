Commit message: Complete rover control task

File: src/intro_rover_description/urdf/intro_rover_description.urdf (robot description, URDF)
Before this commit: robot intro_rover_description, 15 links, 14 joints
Joints:
- joint bl_wheel: axis 0 -1 0 -> 0 1 0
- joint fl_wheel: axis 0 -1 0 -> 0 1 0
